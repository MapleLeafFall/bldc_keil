# Keil uVision project VESC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VESC +hex
  AfterMake: fromelf --bin --output Objects\VESC.bin Objects\VESC.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,HW_VERSION_410, STM32F405xx
  c misc: -USTM32F40_41xxx --gnu
  c include: ..\VESC;.\ChibiOS_3.0.2\os\common\ports\ARMCMx\devices\STM32F4xx;.\ChibiOS_3.0.2\os\ext\CMSIS\include;.\ChibiOS_3.0.2\os\ext\CMSIS\ST;.\ChibiOS_3.0.2\os\rt\ports\ARMCMx;.\ChibiOS_3.0.2\os\rt\ports\ARMCMx\compilers\RVCT;.\ChibiOS_3.0.2\os\rt\include;.\ChibiOS_3.0.2\os\hal\osal\rt;.\ChibiOS_3.0.2\os\hal\include;.\ChibiOS_3.0.2\os\hal\ports\common\ARMCMx;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\DMAv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\I2Cv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\OTGv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\SPIv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\TIMv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\USBv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\GPIOv2;.\ChibiOS_3.0.2\os\hal\ports\STM32\LLD\USARTv1;.\ChibiOS_3.0.2\os\hal\ports\STM32\STM32F4xx;.\ChibiOS_3.0.2\ext\stdperiph_stm32f4\inc;.\hwconf;.\mcconf;.\applications;.\appconf;.\nrf;.\board
  asm misc: --cpreproc
  asm include: ..\VESC;.\ChibiOS_3.0.2\os\common\ports\ARMCMx\devices\STM32F4xx;.\ChibiOS_3.0.2\os\rt\ports\ARMCMx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group board
    ./board/: board.c
  group port
    ./ChibiOS_3.0.2/os/common/ports/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ./ChibiOS_3.0.2/os/rt/ports/ARMCMx/: chcore.c chcore_v7m.c
    ./ChibiOS_3.0.2/os/rt/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s
  group kernel
    ./ChibiOS_3.0.2/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group hal
    ./ChibiOS_3.0.2/os/hal/src/: adc.c can.c ext.c gpt.c hal.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c pal.c pwm.c serial.c serial_usb.c spi.c st.c uart.c usb.c
    ./ChibiOS_3.0.2/os/hal/ports/common/ARMCMx/: nvic.c
  group platform
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/: ext_lld.c can_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/SPIv1/: i2s_lld.c spi_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/I2Cv1/: i2c_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/STM32F4xx/: hal_lld.c ext_lld_isr.c stm32_dma.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c st_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/OTGv1/: usb_lld.c
    ./ChibiOS_3.0.2/os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c uart_lld.c
  group library
    ./ChibiOS_3.0.2/ext/stdperiph_stm32f4/src/: stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_wwdg.c misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group hwconf
    ./hwconf/: hw_410.c hw_victor_r1a.c hw_40.c hw_45.c hw_46.c hw_48.c hw_49.c hw_r2.c
  group vesc
    ./: buffer.c comm_can.c comm_usb.c comm_usb_serial.c commands.c conf_general.c crc.c digital_filter.c eeprom.c encoder.c flash_helper.c irq_handlers.c led_external.c ledpwm.c main.c mc_interface.c mcpwm.c mcpwm_foc.c packet.c servo.c servo_dec.c servo_simple.c terminal.c timeout.c utils.c ws2811.c
  group applications
    ./applications/: app.c app_adc.c app_nunchuk.c app_ppm.c app_sten.c app_uartcomm.c
  group nrf
    ./nrf/: nrf_driver.c rf.c rfhelp.c spi_sw.c
